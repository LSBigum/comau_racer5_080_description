Commit message: Add xacro file with better inertial values

File: urdf/materials.xacro (robot description, xacro)
@@ -25,3 +25,6 @@
     <color rgba="1.0 1.0 1.0 1.0"/>
   </material>
+  <material name="silver">
+    <color rgba="0.700 0.700 0.700 1.000"/>
+  </material>
 </robot>
